UBOOT_VERSION = "v2020.04"

require u-boot-socfpga-common.inc
