UBOOT_VERSION = "v2020.07"

require u-boot-socfpga-common.inc
